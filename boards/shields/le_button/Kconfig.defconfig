## boards/shields/le_button/Kconfig.defconfig
```kconfig
if SHIELD_LE_BUTTON

config ZMK_KEYBOARD_NAME
    default "le-button"

endif # SHIELD_LE_BUTTON
```
